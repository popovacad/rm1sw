# IAR project stm8_rm1sw.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x0
  ICCSTM8.CCDefines: DEBUG
  ICCSTM8.CCIncludePath2: sources\Platform; sources\Platform\SPL
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: stm8_rm1sw.bin
  ILINK.IlinkOutputFile: stm8_rm1sw.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  group (top)
    ./: Resources.txt
  group sources
    sources/: checksum.c checksum.h config.c config.h device.h indication.c indication.h main.c melodies.inc music.c music.h notes_lengths.inc RDM880.c RDM880.h swuart.c swuart.h timing.c timing.h wiegand.c wiegand.h
  group sources/Platform
    sources/Platform/: stm8s_conf.h stm8s_def.h
  group sources/Platform/SPL
    sources/Platform/SPL/: stm8s.h stm8s_clk.c stm8s_clk.h stm8s_exti.c stm8s_exti.h stm8s_flash.c stm8s_flash.h stm8s_gpio.c stm8s_gpio.h stm8s_itc.c stm8s_itc.h stm8s_tim2.c stm8s_tim2.h stm8s_tim3.c stm8s_tim3.h stm8s_tim4.c stm8s_tim4.h
